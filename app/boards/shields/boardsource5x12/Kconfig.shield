## app/boards/shields/boardsource5x12/Kconfig.shield
```kconfig
# Copyright (c) 2021 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_BOARDSOURCE5X12
```
